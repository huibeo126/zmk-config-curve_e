## config/boards/arm/curve_e/Kconfig.board
```kconfig
# Copyright (c) 2021 The ZMK Contributors
# SPDX-License-Identifier: MIT

config BOARD_CURVE_E
	bool "Curve E"
	depends on SOC_NRF52840_QIAA
```
